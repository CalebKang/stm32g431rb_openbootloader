# Keil uVision project stm32g431_iap.uvprojx, settings and files
target stm32g431_iap (ARM-ADS)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.3
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32g431_iap +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;                  ../Drivers/STM32G4xx_HAL_Driver/Inc;                  ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;                  ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                  ../Drivers/CMSIS/Include;                  ..\OpenBootloader\Driver\Core;                  ..\OpenBootloader\Driver\Modules\Mem;                  ..\OpenBootloader\Driver\Modules\USART;                  ..\OpenBootloader\Driver\Modules\FDCAN;                  ..\OpenBootloader\Driver\Modules\I2C;                  ..\OpenBootloader\Target;                  ..\OpenBootloader\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c app_openbootloader.h
  group OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c common_interface.h flash_interface.c flash_interface.h interfaces_conf.h iwdg_interface.c iwdg_interface.h openbootloader_conf.h optionbytes_interface.c optionbytes_interface.h otp_interface.c otp_interface.h platform.h ram_interface.c ram_interface.h systemmemory_interface.c systemmemory_interface.h usart_interface.c usart_interface.h
  group OpenBootloader/Driver/Core
    ../OpenBootloader/Driver/Core/: openbl_core.c openbl_core.h
  group OpenBootloader/Driver/Modules
    ../OpenBootloader/Driver/Modules/Mem/: openbl_mem.c openbl_mem.h
    ../OpenBootloader/Driver/Modules/USART/: openbl_usart_cmd.c openbl_usart_cmd.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_gpio.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c stm32g4xx_ll_dma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
